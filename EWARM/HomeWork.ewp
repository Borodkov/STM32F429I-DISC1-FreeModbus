# IAR project HomeWork.ewp, settings and files
configuration HomeWork (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ..\Drivers\BSP\STM32F429I-Discovery; ..\Middlewares\Third_Party\FreeModbus\modbus\ascii; ..\Middlewares\Third_Party\FreeModbus\modbus\functions; ..\Middlewares\Third_Party\FreeModbus\modbus\include; ..\Middlewares\Third_Party\FreeModbus\modbus\port; ..\Middlewares\Third_Party\FreeModbus\modbus\rtu; ..\Middlewares\Third_Party\FreeModbus\modbus\tcp; ..\Utilities\CPU; ..\Utilities\Log
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: HomeWork.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User
    ../Src/: adc.c dma.c freertos.c gpio.c main.c rtc.c stm32f4xx_hal_msp.c stm32f4xx_it.c tim.c
  group Application/User/Utilities
    ../Utilities/CPU/: cpu_utils.c
    ../Utilities/Log/: lcd_log.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ili9341/: ili9341.c ili9341.h
  group Drivers/BSP/STM32F429-Disco
    ../Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery.h stm32f429i_discovery_lcd.c stm32f429i_discovery_lcd.h stm32f429i_discovery_sdram.c stm32f429i_discovery_sdram.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c
  group Middlewares/FreeModbus
    ../Middlewares/Third_Party/FreeModbus/modbus/: mb.c
  group Middlewares/FreeModbus/ascii
    ../Middlewares/Third_Party/FreeModbus/modbus/ascii/: mbascii.c mbascii.h
  group Middlewares/FreeModbus/functions
    ../Middlewares/Third_Party/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Middlewares/FreeModbus/include
    ../Middlewares/Third_Party/FreeModbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group Middlewares/FreeModbus/port
    ../Middlewares/Third_Party/FreeModbus/modbus/port/: port.h portevent.c portserial.c porttimer.c
  group Middlewares/FreeModbus/rtu
    ../Middlewares/Third_Party/FreeModbus/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group Middlewares/FreeModbus/tcp
    ../Middlewares/Third_Party/FreeModbus/modbus/tcp/: mbtcp.c mbtcp.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
